# Usar WirePlumber como session manager
PIPEWIRE_SESSION_MANAGER = "wireplumber"
